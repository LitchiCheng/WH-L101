# Keil uVision project rename.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: USE_MINI_PRINT
  c misc: --cpp
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\inc;.\Libraries\src;.\Libraries\startup;.\Logger;.\utility;\USER;.\F1HAL;.\USER;.\WH-L101
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: CommonConfig.c stm32f10x_it.c main.cpp LED.c
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group Liberaries
    ./Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c
  group startup
    ./Libraries/startup/: startup_stm32f10x_hd.s
  group Logger
    ./Logger/: rtt_vsnprintf.c Console.cpp SEGGER_RTT.c
  group HAL
    ./F1HAL/: CUsart.cpp Timer.cpp
  group WH-L101
    ./WH-L101/: gpio.c lora.c
